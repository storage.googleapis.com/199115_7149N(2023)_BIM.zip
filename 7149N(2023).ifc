Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-08-01T19:57:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Aug 01 19:57:22 2023 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\fa626124-a7ec-43cf-8695-2e45f57e05a6\d9977131-7ba0-4b6a-8519-0aa6dec8f7b5\ifc * Database version: 5507 * Database creation date: Tue Aug 01 19:57:18 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Aug 01 19:57:19 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Aug 01 19:57:19 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 7149N Bath and shower faucet with shower set, 7149N(2023):7149N Bath and shower faucet with shower set:490545
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 168.173 mm; FaucetNominalHeight: 62.647 mm; FaucetNominalWidth: 342.094 mm; HandShowerNominalDepth: 124.45 mm; HandShowerNominalHeight: 765.13 mm; HandShowerNominalWidth: 236.514 mm
Type - General - Author: BIMStone; BIMObjectName: 7149N(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 6414150099540; EN Standard: EN1111; ETIM Class Number: EC010862 Bath mixing tap; Noise Class 02ls: I (ISO 3822); Sales Package dimensions (LxWxH): 781 x 241 x 79; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/7149N; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/7149N
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7149N; 3D View: https://static.oras.com/AR/7149N; Catalog Drawing URL: http://static.oras.com/catdrw/7149N; Dimension Drawing URL: http://static.oras.com/dimdrw/7149N; FDV Document URL: http://www.oras.com/datasheet/7149N/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7149N; Group: Bath and shower faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/7149N; Interactive AR View URL: https://static.oras.com/AR/7149N; Manufacturer: Oras; Market: International;Finland; Mobile Product Information URL: http://mpi.oras.com/7149N; Model: 7149N Bath and shower faucet with shower set; Name_en: 7149N Bath and shower faucet with shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7149N; Product Family: Oras Optima; Product Image URL: http://static.oras.com/image/7149N; Product URL: http://static.oras.com/7149N; Technical DataSheet URL: http://www.oras.com/datasheet/7149N/en; Type Name: 7149N Bath and shower faucet with shower set; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Flexible length / can be shortened;Hose guide, revolving; Backflow Prevention EN1717: EB; Connection: Straight coupling(s);Direct connection; Connection Size: G3/4; Diverter: Turn operated diverter;Integrated into flow control handle; Eco Flow At 300kPa: 0.00423776 m3/s; Excluded Items: Without couplings; Flow Rate At 300kPa: 0.00776923 m3/s; Hand Shower Size: Ø110; Installation Type: Wall mounted; Installation Width: CC150± 3 mm; Lever Handle: Temperature control handle;Flow control handle;Hot/Cold symbols;Easy-Grip surface;Eco feature for water flow; Max. Hot Water Supply: 65 kg/K/s3; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Mounting Holes: 2 hole; Pressure Loss With Flow 02ls: 250000 Pa; Shower Parts: Hand shower;;Adjustable shower rail bracket;Shower hose (1750 mm);Shower rail;Anti limescale technology (easy to clean);Soap dish;Twist guard for shower hose;Variable fixing points; Shower Spray: Normal;Massage;Rain; Shower Spray Number: 3 shower sprays; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Safety stop against scalding at 38°C;The housing of the fittings conducts minimal heat; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7149N(2023); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 7149N; Name: 7149N Bath and shower faucet with shower set; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 345x170x65 mm / Handshower: 240x125x765 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 7149N Bath and shower faucet with shower set; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7149N; Manufacturer: Oras
Pset_ProductRequirements - Name: 7149N Bath and shower faucet with shower set; Category: Plumbing Fixtures
Constraints - Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 1100 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.396264 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; DistanceX-axis: 0 mm; DistanceY-axis: 0 mm; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.0260647 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7149N(2023): 7149N Bath and shower faucet with shower set; Family and Type: 7149N(2023): 7149N Bath and shower faucet with shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7149N(2023): 7149N Bath and shower faucet with shower set; Type Id: 7149N(2023): 7149N Bath and shower faucet with shower set; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
